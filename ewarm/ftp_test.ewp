# IAR project ftp_test.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=8000000; STM32F4XX; USE_DHCP; SERIAL_DEBUG; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\; ..\http; ..\fs; ..\ftp; ..\sys; ..\periph; ..\tasks; ..\utils; ..\Library\FatFs; ..\Library\CMSIS\Device\ST\STM32F4xx\Include; ..\Library\STM32F4xx_StdPeriph_Driver\inc; ..\Library\STM32F4x7_ETH_Driver\inc; ..\Library\STM32F4-Discovery; ..\Library\lwip\src\include\netif; ..\Library\lwip\src\include\lwip; ..\Library\lwip\src\include\ipv4; ..\Library\lwip\src\include; ..\library\CMSIS\Include\; ..\Library\lwip\port\STM32F4x7\FreeRTOS; ..\Library\lwip\port\STM32F4x7; ..\Library\FreeRTOS\include; ..\Library\FreeRTOS\portable\EWARM\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: ftp_test.srec
  ILINK.IlinkOutputFile: ftp_test.out
  group (top)
    ../: main.c
  group ftp
    ../ftp/: cmds.c ftpd.c
  group Library/FatFs
    ../library/FatFs/: diskio.c ff.c
  group Library/FreeRTOS
    ../library/FreeRTOS/: croutine.c list.c queue.c tasks.c
  group Library/FreeRTOS/portable
    ../library/FreeRTOS/portable/MemMang/: heap_2.c
    ../library/FreeRTOS/portable/EWARM/ARM_CM3/: port.c portasm.s
  group Library/LWIP
    ../library/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../library/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../library/lwip/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../library/lwip/src/netif/: etharp.c loopif.c slipif.c
    ../library/lwip/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group Library/STM32F4-Discovery
    ../library/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c stm32f4_discovery_sdio_sd.c
  group Library/STM32F4x7_ETH_Driver
    ../library/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Library/STM32F4xx_StdPeriph_Driver
    ../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group periph
    ../periph/: led.c stm32f4x7_eth_bsp.c usart1.c
  group sys
    ../sys/: startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c
  group tasks
    ../tasks/: netconf.c
  group utils
    ../utils/: userfunc.c
